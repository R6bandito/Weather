# Keil uVision project proj.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: .\Drivers\CMSIS\Device\ST\STM32F4\Inc;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\ST\STM32F4;.\Drivers\HAL\Inc;.\Core\Inc;.\Drivers\HAL\Inc\Legacy;.\Drivers\BSP;.\Middleware\RTOS\Core\Inc;.\Middleware\RTOS\Portable;.\Middleware\RTOS;.\Hardware
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Driver/CMSIS/Inc
    ./Drivers/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
  group Driver/CMSIS/Device/Inc
    ./Drivers/CMSIS/Device/ST/STM32F4/Inc/: stm32f4xx.h stm32f407xx.h system_stm32f4xx.h
    ./Drivers/HAL/Inc/: stm32f4xx_hal_gpio_ex.h
  group Driver/CMSIS/Device/Src
    ./Drivers/CMSIS/Device/ST/STM32F4/Src/: system_stm32f4xx.c
  group Driver/BSP
    ./Drivers/BSP/: bsp_usart_debug.c bsp_usart_debug.h Perp_clkEn.c Perp_clkEn.h rtos_hook.c rtos_hook.h
  group Driver/CMSIS/HAL/Inc
    ./Drivers/HAL/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_sram.h stm32f4xx_ll_fsmc.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h
    ./Drivers/HAL/Inc/Legacy/: stm32_hal_legacy.h stm32f4xx_hal_can_legacy.h
  group Driver/CMSIS/HAL/Src
    ./Drivers/HAL/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
    ./Drivers/HAL/Src/Legacy/: stm32f4xx_hal_can.c
  group Driver/CMSIS/Conf
    ./Drivers/HAL/Inc/: stm32f4xx_hal_conf.h
  group RTOS/Core/Src
    ./Middleware/RTOS/Core/Src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group RTOS/Core/Inc
    ./Middleware/RTOS/Core/Inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group RTOS/Portable
    ./Middleware/RTOS/Portable/: heap_4.c port.c portmacro.h
  group RTOS/Conf
    ./Middleware/RTOS/: FreeRTOSConfig.h
  group Core/Inc
    ./Core/Inc/: main.h stm32f4xx_it.h Mspinit.h
  group Core/Src
    ./Core/Src/: main.c stm32f4xx_it.c Mspinit.c
  group START
    ./Drivers/CMSIS/Device/ST/STM32F4/: startup_stm32f407xx.s
  group Hardware
    ./Hardware/: hal_timebase.c hal_timebase.h task_Exam.c task_Exam.h
